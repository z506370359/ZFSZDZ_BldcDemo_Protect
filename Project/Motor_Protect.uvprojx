# Keil uVision project Motor_Protect.uvprojx, settings and files
target BLDC_CONTROL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G030C8Tx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Include
    ../Include/: stm32g030xx.h Define.h UserParams.h Main.h Initialize.h Adc.h Motor.h Usart.h Protect.h Display.h LCD.h LCDfont.h BLDC.h MathCalc.h PID.h
  group Source
    ../Source/: Main.c Startup.s Initialize.c Adc.c Motor.c Usart.c Protect.c Display.c LCD.c BLDC.c MathCalc.c PID.c
  group ReadMe
    ../Describe/: ReadMe.txt
